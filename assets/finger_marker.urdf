Commit message: new starting pos

File: assets/finger_marker.urdf (robot description, URDF)
Before this commit: robot finger_marker.urdf, 1 links, 0 joints
Links:
- link f_marker: geometry visual cylinder length=0.05 radius=0.005
