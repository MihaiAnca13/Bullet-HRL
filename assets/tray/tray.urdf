Commit message: Single Agent Control

File: assets/tray/tray.urdf (robot description, URDF)
Before this commit: robot tray, 1 links, 0 joints
Links:
- link tray_base_link: geometry collision mesh filename=tray_textured4.obj scale=1 1 0.5; visual mesh filename=tray_textured4.obj scale=1 1 0.5
