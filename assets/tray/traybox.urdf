Commit message: Includes two boxes and two arms

File: assets/tray/traybox.urdf (robot description, URDF)
Before this commit: robot tabletop, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=.02 .6 .15; collision box size=.02 .6 .15
